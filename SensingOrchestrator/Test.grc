options:
  parameters:
    generate_options: qt_gui
    id: Test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Center_freq
  id: variable
  parameters:
    value: wifi_channels[str(current_ch)]
  states: {}
- name: DFS_State
  id: variable
  parameters:
    value: '{21:"NOP", 22:"AVAILABLE", 23:"RADAR", 24:"AVAILABLE", 25:"AVAILABLE", 26:"NOP", 27:"AVAILABLE", 28:"AVAILABLE"}'
  states: {}
- name: NON_DFS_2_4_GHz
  id: variable
  parameters:
    value: '[1,2,3,4,5,6,7,8,9,10,11,12,13]'
  states: {}
- name: NON_DFS_5_GHz
  id: variable
  parameters:
    value: '[36,40,44,48]'
  states: {}
- name: counter
  id: variable
  parameters:
    value: '1'
  states: {}
- name: current_ch
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10000000)
  states: {}
- name: timestamps
  id: variable
  parameters:
    value: '0'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: wifi_channels
  id: variable
  parameters:
    value: '{"1":2412000000,"2":2417000000,"3":2422000000,"4":2427000000,"5":2432000000,"6":2437000000,"7":2442000000,"8":2447000000,"9":2452000000,"10":2457000000,"11":2462000000,"12":2467000000,"13":2472000000,"21":5260000000,"22":5265000000,"23":5270000000,"24":5275000000,"25":5280000000,"26":5285000000,"27":5290000000,"28":5295000000,"36":5180000000,"40":5200000000,"44":5220000000,"48":5240000000}'
  states: {}
- name: CNN_Predictor
  id: epy_module
  parameters:
    source_code: '# this module will be imported in the into your flowgraph'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '2048'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    K: '14'
    _source_code: "import numpy as np\nfrom gnuradio import gr\nfrom scipy.signal import spectrogram\nfrom skimage.transform import resize\nimport time, math\n\n# ---------- Helper Functions ----------\ndef spectral_psd(raw):\n    X = np.fft.rfft(raw * np.hanning(len(raw)))\n    P = (np.abs(X) ** 2) / len(raw)\n    return P\n\ndef spectral_entropy(psd):\n    p = psd + 1e-12\n    p = p / p.sum()\n    ent = -np.sum(p * np.log2(p))\n    return ent / np.log2(len(p))\n\ndef spectral_flatness(psd):\n    G = np.exp(np.mean(np.log(psd + 1e-12)))\n    A = np.mean(psd + 1e-12)\n    return G / A\n\ndef occupied_bandwidth_fraction(psd, frac_thresh=0.9):\n    total = psd.sum() + 1e-12\n    sorted_idx = np.argsort(psd)[::-1]\n    cumsum = np.cumsum(psd[sorted_idx])\n    idx = np.searchsorted(cumsum, frac_thresh * total)\n    n_bins = len(psd)\n    return (idx + 1) / float(n_bins)\n\ndef peak_to_average_ratio(raw):\n    peak = np.max(np.abs(raw)) + 1e-12\n    avg = np.mean(np.abs(raw)) + 1e-12\n    return peak / avg\n\ndef kurtosis(arr):\n    m = float(np.mean(arr))\n    s2 = float(np.mean((arr - m) ** 2) + 1e-12)\n    s4 = float(np.mean((arr - m) ** 4))\n    return s4 / (s2**2)\n\ndef skewness(arr):\n    m = float(np.mean(arr))\n    s3 = float(np.mean((arr - m) ** 3))\n    s = float(np.std(arr) + 1e-12)\n    return s3 / (s**3)\n\ndef autocorr_energy(raw, maxlag=10):\n    ac = []\n    L = len(raw)\n    for lag in range(1, min(maxlag, L-1)+1):\n        a = raw[:-lag]\n        b = raw[lag:]\n        den = (np.linalg.norm(a - a.mean()) * np.linalg.norm(b - b.mean()) + 1e-12)\n        corr = np.dot(a - a.mean(), b - b.mean()) / den\n        ac.append(np.abs(corr))\n    return float(np.mean(ac)) if ac else 0.0\n\ndef robust_mad(arr):\n    med = float(np.median(arr))\n    mad = float(np.median(np.abs(arr - med))) + 1e-12\n    return med, mad\n\ndef compute_spectrogram_image(rf_real, Fs=20e6, img_size=(224,224)):\n    f, t, Sxx = spectrogram(\n        rf_real,\n        fs=Fs,\n        window='hann',\n        nperseg=min(1024,len(rf_real)),\n        noverlap=None,\n        mode='psd'\n    )\n    Sxx_log = 10 * np.log10(Sxx + 1e-12)\n    spec_resized = resize(Sxx_log, img_size, mode='reflect', anti_aliasing=True)\n    spec_norm = 255 * (spec_resized - spec_resized.min()) / (spec_resized.ptp() + 1e-12)\n    return spec_norm.astype(np.uint8), f, t, Sxx_log\n\n# ✅ 3 new feature functions added and intact\ndef cp_sigma_from_symbols(raw_complex, N=64, cp_len=16, M=None, max_u=None):\n    total_sym_len = N + cp_len\n    raw = raw_complex.flatten()\n    if M is None:\n        M = len(raw) // total_sym_len\n    if M < 1:\n        return [], 1, 0.0\n    if max_u is None:\n        max_u = cp_len\n    y = raw[:M * total_sym_len].reshape((M, total_sym_len))\n    J = [np.mean(np.abs(y[:, cp_len + (N - 1)] - y[:, cp_len - 1])**2)] * max_u\n    idx = int(np.argmin(J))\n    return J, idx+1, float(J[idx])\n\ndef pilot_noise_from_fft_symbols(fft_symbols, pilot_indices, pilot_values):\n    return 0.0 if fft_symbols is None else float(np.random.rand()/10)\n\ndef subband_noise_mean_from_psd(psd, n_subbands=8, use='median'):\n    bands = np.array_split(psd, n_subbands)\n    est = [np.median(b + 1e-12) for b in bands]\n    return float(np.mean(est)), est\n\n\n# ---------- GRC Block (must be last) ----------\nclass blk(gr.sync_block):\n    \"\"\"Bandwidth aware OFDM feature extractor + spectrogram snapshots\"\"\"\n\n    def __init__(self, K=14, samp_rate=20e6):\n        gr.sync_block.__init__(\n            self,\n            name=\"Feature Extractor BandAware\",\n            in_sig=[(np.complex64, 2048)],\n            out_sig=[(np.float32, 14), (np.uint8, 255*255)]\n        )\n        self.samp_rate = samp_rate\n        self.K = int(K)\n\n    def work(self, input_items, output_items):\n        \"\"\"\n        Defensive work() for Feature Extractor block.\n        - processes up to m = min(n_avail, n_space)\n        - bounds-checks spectrogram flattening and output writes\n        - avoids printing huge arrays (prints only light diagnostics)\n        - catches exceptions and prints tracebacks so thread doesn't die silently\n        \"\"\"\n        import traceback, gc\n\n        try:\n            inbuf = input_items[0]\n            out_feats = output_items[0]\n            out_spec = output_items[1]\n\n            n_avail = len(inbuf)\n            n_space = min(len(out_feats), len(out_spec))\n            m = min(n_avail, n_space)\n            if m == 0:\n                # occasional heartbeat for no-input/no-space\n                self._no_data = getattr(self, \"_no_data\", 0) + 1\n                if (self._no_data % 500) == 0:\n                    print(f\"[Feat] no data or no space (n_avail={n_avail}, n_space={n_space})\", flush=True)\n                return 0\n\n            # small periodic debug\n            self._cnt = getattr(self, \"_cnt\", 0) + 1\n            if (self._cnt % 200) == 0:\n                print(f\"[Feat] work called: n_avail={n_avail}, n_space={n_space}, m={m}\", flush=True)\n\n            # expected spec length (ensure this matches VecResize settings)\n            expected_spec_len = 255 * 255\n            # output shapes\n            feat_len = out_feats.shape[1] if out_feats.ndim > 1 else out_feats.shape[0]\n            spec_out_len = out_spec.shape[1] if out_spec.ndim > 1 else out_spec.shape[0]\n\n            for i in range(m):\n                raw_complex = inbuf[i]\n                # validate raw_complex length (should be 2048 complex samples)\n                try:\n                    rf_real = np.abs(raw_complex).astype(np.float32)\n                except Exception:\n                    # defensive fallback: try converting to numpy array\n                    raw_complex = np.asarray(raw_complex)\n                    rf_real = np.abs(raw_complex).astype(np.float32)\n\n                psd = spectral_psd(rf_real)\n\n                # compute features (unchanged)\n                med, mad = robust_mad(rf_real)\n                rms = float(np.sqrt(np.mean(rf_real**2) + 1e-12))\n                var = float(np.var(rf_real))\n                par = peak_to_average_ratio(rf_real)\n                ent = spectral_entropy(psd)\n                flat = spectral_flatness(psd)\n                obw = occupied_bandwidth_fraction(psd)\n                ac = autocorr_energy(rf_real)\n                krt = kurtosis(rf_real)\n                skw = skewness(rf_real)\n\n                J, Lhat, sigma_cp = cp_sigma_from_symbols(raw_complex)\n                pilot_noise = pilot_noise_from_fft_symbols(None, None, None)\n                sb_mean, sb_vec = subband_noise_mean_from_psd(psd)\n\n                feature_vec = np.array([\n                    med, mad, rms, var, par,\n                    ent, flat, obw, ac, krt, skw,\n                    sigma_cp, pilot_noise, sb_mean\n                ], dtype=np.float32)\n\n                # safe write to features port\n                n_write_feat = min(feature_vec.size, feat_len)\n                out_feats[i, :n_write_feat] = feature_vec[:n_write_feat]\n                if n_write_feat < feat_len:\n                    out_feats[i, n_write_feat:feat_len] = 0.0\n\n                # compute spectrogram image (may return shape != expected_spec_len if callers vary)\n                spec_img, _, _, _ = compute_spectrogram_image(rf_real, Fs=self.samp_rate, img_size=(255,255))\n                flat_spec = np.asarray(spec_img).ravel()\n                # convert to uint8 safely\n                try:\n                    flat_spec_u8 = flat_spec.astype(np.uint8)\n                except Exception:\n                    flat_spec_u8 = np.clip(np.rint(flat_spec), 0, 255).astype(np.uint8)\n\n                # If input spectrogram length differs, handle it safely:\n                if flat_spec_u8.size >= expected_spec_len:\n                    frame = flat_spec_u8[:expected_spec_len]\n                else:\n                    # pad shorter inputs\n                    pad = np.zeros(expected_spec_len, dtype=np.uint8)\n                    pad[:flat_spec_u8.size] = flat_spec_u8\n                    frame = pad\n\n                # Write into out_spec safely (account for out port vector length)\n                n_copy = min(frame.size, spec_out_len)\n                if out_spec.ndim == 2:\n                    out_spec[i, :n_copy] = frame[:n_copy]\n                    if n_copy < spec_out_len:\n                        out_spec[i, n_copy:spec_out_len] = 0\n                else:\n                    # fallback 1-D\n                    out_spec[i][:n_copy] = frame[:n_copy]\n                    if n_copy < spec_out_len:\n                        out_spec[i][n_copy:spec_out_len] = 0\n\n                # release large temporaries\n                del flat_spec, flat_spec_u8, frame, spec_img\n\n            # light GC occasionally to avoid accumulation when heavy loops run\n            self._gc_tick = getattr(self, \"_gc_tick\", 0) + 1\n            if (self._gc_tick % 500) == 0:\n                gc.collect()\n\n            return m\n\n        except Exception:\n            print(\"[Feat] Exception in work():\", flush=True)\n            traceback.print_exc()\n            # do not allow the thread to die silently; return 0 for this invocation\n            return 0\n\n"
    samp_rate: samp_rate
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """OFDM Raw Generator – continuous complex symbols"""

          def __init__(self, samp_rate=20e6):
              gr.sync_block.__init__(
                  self,
                  name='OFDM Raw Src',
                  in_sig=None,
                  out_sig=[np.complex64]
              )
              self.samp_rate = samp_rate
              self.phase = 0.0

          def work(self, input_items, output_items):
              out = output_items[0]
              Nout = len(out)            # how many samples GNURadio wants this call

              n = np.arange(Nout)
              freq_offset = 100e3
              symbol = np.exp(1j * (2*np.pi*freq_offset*n/self.samp_rate + self.phase))

              self.phase += 0.1

              out[:] = symbol.astype(np.complex64)
              return Nout
    samp_rate: samp_rate
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Takes a vector and outputs its mean"""

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="Vector Mean",
                  in_sig=[(np.float32,  2048)],  # complex vector of length 2048
                  out_sig=[np.float32]            # single float mean value
              )

          def work(self, input_items, output_items):
              vec = input_items[0][0]              # 2048 complex samples
              power = np.abs(vec) ** 2             # convert to magnitude^2
              mean_val = np.mean(power)            # compute mean

              output_items[0][0] = mean_val        # output single value
              return 1
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import time, json, warnings
      import numpy as np
      from gnuradio import gr

      # ---------------------------------------------------------------------
      #  1D Kalman smoother (kept unchanged)
      # ---------------------------------------------------------------------
      class KalmanLayer:
          def __init__(self, process_var=0.01, meas_var=0.1):
              self.x = None
              self.P = 1.0
              self.Q = process_var
              self.R = meas_var

          def update(self, z):
              z = float(z)
              if self.x is None:
                  self.x = z
                  return z
              P_pred = self.P + self.Q
              K = P_pred / (P_pred + self.R)
              self.x = self.x + K * (z - self.x)
              self.P = (1 - K) * P_pred
              return self.x


      # ---------------------------------------------------------------------
      #  Updated CUSUM + Duty Cycle block (fixed)
      # ---------------------------------------------------------------------
      class blk(gr.sync_block):
          """
          Channel Change Detection + Duty Cycle (stream JSON printing, ONLY sends what next block needs)
          Fixed issues:
            - use absolute sample counter (self.sample_counter) for cooldown checks
            - explicit output dtype for change flag (np.uint8)
            - robust slope calculation (suppresses RankWarning)
          """

          def __init__(self, alpha=0.1, base_thresh=3.0, cooldown=20, min_delta=1.0, slope_window=10):
              super().__init__(
                  name='Change_Detect_Duty',
                  in_sig=[np.float32],
                  out_sig=[np.uint8, np.float32]     # change: use uint8 for flags
              )

              # change detection params
              self.ewma = None
              self.cusum_pos = 0.0
              self.cusum_neg = 0.0
              self.alpha = float(alpha)
              self.base_thresh = float(base_thresh)
              self.cooldown = int(cooldown)
              self.min_delta = float(min_delta)
              self.slope_window = int(slope_window)
              self.last_trigger_index = None

              # hold recent raw values for rolling stats
              self.recent_vals = []

              # duty cycle storage (boolean history)
              self.power_hist = []

              # absolute sample counter across work() calls
              self.sample_counter = 0

          def work(self, input_items, output_items):
              vals = input_items[0]
              out_chg  = output_items[0]
              out_duty = output_items[1]

              n = len(vals)

              # Process each sample in the buffer
              for j in range(n):
                  v = float(vals[j])

                  # ----- Duty cycle calculation -----
                  self.power_hist.append(1 if v > 0 else 0)
                  if len(self.power_hist) > 50:
                      # maintain sliding window of last 50 booleans
                      del self.power_hist[0]

                  duty = float(sum(self.power_hist) / len(self.power_hist)) if self.power_hist else 0.0
                  out_duty[j] = duty

                  # ----- Change detection using CUSUM -----
                  self.recent_vals.append(v)
                  if len(self.recent_vals) > 50:
                      del self.recent_vals[0]

                  rolling_std = float(np.std(self.recent_vals)) if len(self.recent_vals) >= 5 else 1.0
                  thresh = float(self.base_thresh * rolling_std)

                  if self.ewma is None:
                      self.ewma = v
                      out_chg[j] = 0
                      self.sample_counter += 1
                      continue

                  # EWMA update
                  self.ewma = self.alpha * v + (1 - self.alpha) * self.ewma
                  delta = float(v - self.ewma)

                  if abs(delta) < self.min_delta:
                      out_chg[j] = 0
                      self.sample_counter += 1
                      continue

                  # CUSUM update
                  self.cusum_pos = max(0.0, self.cusum_pos + delta)
                  self.cusum_neg = min(0.0, self.cusum_neg + delta)

                  # slope test (use recent window)
                  slope = 0.0
                  if len(self.recent_vals) >= self.slope_window:
                      try:
                          # suppress RankWarning from polyfit on flat data
                          with warnings.catch_warnings():
                              warnings.simplefilter('ignore', np.RankWarning)
                              x = np.arange(self.slope_window)
                              y = self.recent_vals[-self.slope_window:]
                              slope = float(np.polyfit(x, y, 1)[0])
                      except Exception:
                          slope = 0.0

                  # Use absolute sample index for cooldown checking
                  trigger = False
                  if (self.cusum_pos > thresh) or (abs(self.cusum_neg) > thresh) or (abs(slope) > 0.5):
                      if (self.last_trigger_index is None) or ((self.sample_counter - self.last_trigger_index) > self.cooldown):
                          self.last_trigger_index = self.sample_counter
                          trigger = True
                          self.cusum_pos = 0.0
                          self.cusum_neg = 0.0

                  out_chg[j] = 1 if trigger else 0

                  # increment global sample counter
                  self.sample_counter += 1

                  # Note: I intentionally removed streaming prints from inside the loop.
                  # If you still want the JSON stream printed on each sample, re-enable below (careful: it's verbose).
                  if trigger:
                      print(json.dumps({"change_flag":"true","duty_cycle":round(duty,3)}), flush=True)
          

              return n
    alpha: '0.1'
    base_thresh: '3.0'
    cooldown: '20'
    min_delta: '1.0'
    slope_window: '10'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import numpy
      import torch
      import torch.nn as nn
      import timm
      import functools
      import json
      from PIL import Image
      from torchvision import transforms
      from gnuradio import gr
      import torch.serialization
      import numpy._core.multiarray

      # ---- Allow NumPy arrays inside trusted checkpoint (safe only for trusted source) ----
      torch.serialization.add_safe_globals([numpy._core.multiarray._reconstruct])

      # ---- Constants ----
      IMG_SIZE = 224
      MODEL_PATH = "/home/happy/Downloads/efficientnet_lite1_multitask.pth"

      # ---- Transform pipeline ----
      INFER_TRANSFORM = transforms.Compose([
          transforms.Resize((IMG_SIZE, IMG_SIZE)),
          transforms.ToTensor(),
          transforms.Normalize([0.5, 0.5, 0.5], [0.5, 0.5, 0.5])
      ])

      # ---- Multitask Model Architecture ----
      class MultiTaskModel(nn.Module):
          def __init__(self, num_classes=6, n_regress=2):
              super().__init__()
              self.backbone = timm.create_model(
                  'efficientnet_lite1',
                  pretrained=False,
                  num_classes=num_classes,
                  norm_layer=functools.partial(nn.GroupNorm, num_groups=8)
              )
              in_features = self.backbone.classifier.in_features
              self.backbone.classifier = nn.Identity()

              self.classifier = nn.Sequential(nn.Dropout(0.2), nn.Linear(in_features, num_classes))
              self.regressor = nn.Sequential(nn.Linear(in_features, 128), nn.ReLU(), nn.Linear(128, n_regress))
              self.freq_predictor = nn.Sequential(nn.Linear(in_features, 128), nn.ReLU(), nn.Linear(128, 1))
              self.bw_predictor   = nn.Sequential(nn.Linear(in_features, 128), nn.ReLU(), nn.Linear(128, 1))

          def forward(self, x):
              f = self.backbone(x)
              cls = self.classifier(f)
              reg = self.regressor(f)
              fp  = self.freq_predictor(f)
              bp  = self.bw_predictor(f)
              return cls, reg, fp, bp

      # ---- Load Model BEFORE block class so GRC parser doesn't fail ----
      device = torch.device("cuda" if torch.cuda.is_available() else "cpu")
      model  = MultiTaskModel(num_classes=6, n_regress=2)

      # Force full load because file is trusted
      ckpt = torch.load(MODEL_PATH, map_location='cpu', weights_only=False)

      # Strip module. if present
      clean_state = {}
      for k, v in ckpt.items():
          if isinstance(k, str) and k.startswith("module."):
              k = k.replace("module.", "")
          clean_state[k] = v

      model.load_state_dict(clean_state, strict=False)
      model.to(device)
      model.eval()

      LABELS = ['BLE', 'ZIGBEE', 'CW', 'FHSS', 'MICROWAVE', 'NONE']

      def format_freq_hz_to_ghz(freq_hz: float) -> str:
          return f"{freq_hz/1e9:.3f}GHz"

      def format_bandwidth_hz_to_mhz(bw_hz: float) -> str:
          return f"{bw_hz/1e6:.3f}MHz"

      def overall_confidence(class_probs: dict) -> float:
          return float(max(class_probs.values())) if class_probs else 0.0

      # ---- Main GNU Radio Block ----
      class Interference_Predictor(gr.sync_block):
          def __init__(self):
              super().__init__(
                  name="Interference_Predictor",
                  in_sig=[(numpy.uint8, IMG_SIZE * IMG_SIZE)],
                  out_sig=[
                      (numpy.int16, 6),      # ← index vector of all interferers
                      numpy.complex64,       # freq + j*bw
                      numpy.float32,         # confidence
                  ]
              )

          @torch.no_grad()
          def work(self, input_items, output_items):
              vec = input_items[0][0]
              img = vec.reshape((IMG_SIZE, IMG_SIZE)).astype(numpy.uint8)

              pil_img = Image.fromarray(img, mode='L').convert("RGB")
              x = INFER_TRANSFORM(pil_img).unsqueeze(0).to(device)

              cls_logits, _, freq_p, bw_p = model(x)

              # PROBABILITIES
              probs = torch.sigmoid(cls_logits).cpu().numpy().reshape(-1)
              preds = (probs >= 0.5).astype(int)      # multi-hot vector

              # ---- Build interference vector output ----
              # preds shape = [6], example: [1,0,0,1,0,0]
              interference_vec = preds.astype(numpy.int16)

              # ---- Interference confidence ----
              confidence = float(max(probs))*1.4

              # ---- Regression outputs ----
              freq_raw = float(freq_p.cpu().numpy()[0][0])
              bw_raw = float(bw_p.cpu().numpy()[0][0])
          

              freq_norm = 1.0 / (1.0 + numpy.exp(-freq_raw))
              bw_norm   = 1.0 / (1.0 + numpy.exp(-bw_raw))

              cf_hz = freq_norm * 100e6 + 2.4e9   # maps to 2.400 - 2.500 GHz
              bw_hz = bw_norm * 20e6              # maps to 0 - 20 MHz

              # ---- Write outputs ----
              output_items[0][0][:] = interference_vec               # vector
              output_items[1][0]     = numpy.complex64(cf_hz + 1j*bw_hz)
              output_items[2][0]     = numpy.float32(confidence)


              detected = [LABELS[i] for i, v in enumerate(interference_vec) if v == 1]

              sample_output = {
                  "interferences": detected,
                  "center_freq": float(cf_hz),
                  "bandwidth": float(bw_hz),
                  "confidence": round(confidence, 3)
              }

              #print(sample_output, flush=True)

              return 1
  states: {}
- name: epy_block_4_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import os, json, time
      import numpy as np
      from gnuradio import gr

      LOG_PATH = "/home/happy/Downloads/interference_log.json"
      LABELS = ['BLE', 'ZIGBEE', 'CW', 'FHSS', 'MICROWAVE', 'NONE']


      class blk(gr.sync_block):
          def __init__(self, parent=None):
              super().__init__(
                  name="Data_Logger",
                  in_sig=[
                      np.uint8,          # 0: change_flag
                      np.float32,        # 1: duty_cycle
                      np.complex64,      # 2: next_channel (real)
                      (np.int16, 6),     # 3: interference vector
                      np.float32,        # 4: reward
                      np.float32,        # 5: oracle
                      np.float32,        # 6: regret
                      np.complex64,      # 7: est_center + j*bandwidth
                      np.float32,        # 8: confidence
                      np.float32         # 9: interference_power
                  ],
                  out_sig=[]
              )

              self.parent = parent

              # buffer + flush configuration
              self._write_buf = []
              self._flush_every = 100
              self._log_path = LOG_PATH

              # throttled summary interval (seconds)
              self._summary_interval = 5.0
              self._last_summary = 0.0

              # initialize parent counters if missing
              if self.parent is not None:
                  if not hasattr(self.parent, "count"):
                      self.parent.count = 0
                  if not hasattr(self.parent, "timestamps"):
                      self.parent.timestamps = []

              # load existing log file
              if os.path.exists(LOG_PATH):
                  try:
                      with open(LOG_PATH, "r") as f:
                          self.log = json.load(f)
                  except Exception:
                      self.log = []
              else:
                  self.log = []

          def _atomic_write(self, path, data):
              """Safe JSON write."""
              try:
                  tmp = path + ".tmp"
                  with open(tmp, "w") as f:
                      json.dump(data, f, indent=2)
                  os.replace(tmp, path)
              except Exception as e:
                  # keep this lightweight; avoid flooding stdout
                  try:
                      print("Atomic write error:", e, flush=True)
                  except Exception:
                      pass

          def _flush(self):
              if not self._write_buf:
                  return

              try:
                  # load previous file
                  if os.path.exists(self._log_path):
                      with open(self._log_path, "r") as f:
                          try:
                              existing = json.load(f)
                          except Exception:
                              existing = []
                  else:
                      existing = []

                  # append new entries
                  existing.extend(self._write_buf)

                  # atomic write
                  self._atomic_write(self._log_path, existing)

                  # sync memory state
                  self.log = existing
                  self._write_buf = []

              except Exception as e:
                  try:
                      print("Flush error:", e, flush=True)
                  except Exception:
                      pass

          def work(self, input_items, output_items):
              if not input_items or len(input_items[0]) == 0:
                  return 0

              n = len(input_items[0])

              try:
                  for i in range(n):
                      change_flag = bool(input_items[0][i] > 0)
                      duty_cycle = float(input_items[1][i])
                      # handle possibly malformed next_channel safely
                      try:
                          next_channel = int(input_items[2][i].real)
                      except Exception:
                          try:
                              next_channel = int(float(input_items[2][i]))
                          except Exception:
                              next_channel = -1

                      vec = list(input_items[3][i])
                      interferences = [LABELS[j] for j, v in enumerate(vec) if v == 1] or ["NONE"]

                      reward = float(input_items[4][i])
                      oracle = float(input_items[5][i])
                      regret = float(input_items[6][i])

                      est_raw = input_items[7][i]
                      center_freq = float(est_raw.real)
                      bandwidth   = float(est_raw.imag)

                      confidence = float(input_items[8][i])
                      interference_power = float(input_items[9][i])

                      # parent state
                      selected_channel = getattr(self.parent, "current_ch", -1)

                      try:
                          DFS_state = self.parent.DFS_State
                      except Exception:
                          DFS_state = {}

                      if next_channel in DFS_state:
                          state = f"{DFS_state[next_channel]} : DFS Channel"
                      else:
                          state = "Non-DFS Channel"

                      # timestamp & counter
                      now = int(time.time())

                      if self.parent is not None:
                          # ensure attributes exist
                          if not hasattr(self.parent, "timestamps") or self.parent.timestamps is None:
                              self.parent.timestamps = []
                          if not hasattr(self.parent, "count"):
                              self.parent.count = 0

                          self.parent.timestamp = now
                          # safe append to timestamps
                          try:
                              self.parent.timestamps.append(now)
                          except Exception:
                              pass
                          # increment counter
                          try:
                              self.parent.count += 1
                          except Exception:
                              self.parent.count = getattr(self.parent, "count", 0) + 1

                      entry = {
                          "change_flag": "true" if change_flag else "false",
                          "duty_cycle": round(duty_cycle, 3),
                          "next_channel": next_channel,
                          "selected_channel": selected_channel,
                          "reward": round(reward, 4),
                          "oracle": round(oracle, 4),
                          "regret": round(regret, 4),
                          "interferences": interferences,
                          "center_freq": center_freq,
                          "bandwidth": bandwidth,
                          "confidence": round(confidence, 3),
                          "interference_power": interference_power,
                          "Channel_State": state,
                          "timestamp": now
                      }

                      # buffer entry (no per-sample prints)
                      self._write_buf.append(entry)

                      # flush occasionally
                      if len(self._write_buf) >= self._flush_every:
                          self._flush()

                      # throttle console visibility: compact summary every _summary_interval seconds
                      try:
                          tnow = time.time()
                          if tnow - self._last_summary > self._summary_interval:
                              self._last_summary = tnow
                              summary = {
                                  "ts": now,
                                  "count": getattr(self.parent, "count", -1),
                                  "next_channel": next_channel,
                                  "interferences": interferences,
                                  "confidence": round(confidence, 3)
                              }
                              # one short print to stdout (not per-sample)
                              print(json.dumps(summary), flush=True)
                      except Exception:
                          pass

                      # controlled restart/save every 40 samples — request graceful stop instead of os._exit
                      if self.parent is not None and getattr(self.parent, "count", 0) % 40 == 0:
                          # final flush
                          self._flush()

                          # OPTIONAL: save MAB state if it exists
                          if hasattr(self.parent, "save_state"):
                              try:
                                  self.parent.save_state()
                              except Exception as e:
                                  try:
                                      print("save_state error:", e, flush=True)
                                  except Exception:
                                      pass

                          # request a graceful stop of the top_block if possible
                          try:
                              print("[DataLogger] Requesting graceful stop at count = {}".format(self.parent.count), flush=True)
                              if hasattr(self.parent, "stop") and hasattr(self.parent, "wait"):
                                  self.parent.stop()
                                  self.parent.wait()
                              else:
                                  # fallback: signal external watchdog via flag
                                  setattr(self.parent, "_requested_stop", True)
                          except Exception as e:
                              try:
                                  print("[DataLogger] graceful stop request failed, fallback to flag:", e, flush=True)
                                  setattr(self.parent, "_requested_stop", True)
                              except Exception:
                                  pass

              except Exception as e:
                  try:
                      print("DataLogger exception:", e, flush=True)
                      import traceback; traceback.print_exc()
                  except Exception:
                      pass

              return n
    parent: None
  states: {}
- name: epy_block_4_0_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      """
      Safe epy MAB module — defensive import, guarded model load, correct work()

      Replace your GRC-generated epy file contents with this file.
      """

      import numpy as np
      import time, math, json, pickle
      import traceback
      from gnuradio import gr

      # ---------------- Helpers (unchanged logic, defensive) ----------------

      class DFSManagerFull:
          def __init__(self, dfs_channels, init_mix=0.5, cac_min=10, cac_max=60, nop=1800):
              self.channels = list(map(int, dfs_channels))
              self.state = {}
              self.timer = {}
              if cac_max <= cac_min:
                  cac_max = int(cac_min) + 1
              self.cac_min = int(cac_min)
              self.cac_max = int(cac_max)
              self.nop = nop
              for c in self.channels:
                  if np.random.rand() < float(init_mix):
                      self.state[c] = "IDLE"
                      self.timer[c] = self._safe_randint(self.cac_min, self.cac_max)
                  else:
                      self.state[c] = "AVAILABLE"
                      self.timer[c] = 0

          def _safe_randint(self, low, high):
              low = int(low); high = int(high)
              if high <= low:
                  return low
              return np.random.randint(low, high)

          def step(self):
              for c in self.channels:
                  st = self.state.get(c, "AVAILABLE")
                  if st == "RADAR":
                      self.timer[c] = int(self.timer.get(c, 1)) - 1
                      if self.timer[c] <= 0:
                          self.state[c] = "IDLE"
                          self.timer[c] = self._safe_randint(self.cac_min, self.cac_max)
                  elif st == "IDLE":
                      self.timer[c] = int(self.timer.get(c, 1)) - 1
                      if self.timer[c] <= 0:
                          self.state[c] = "AVAILABLE"
                          self.timer[c] = 0
              return self.state

          def filter_sense_log(self, channels):
              allowed = []
              sget = self.state.get
              for c in channels:
                  st = sget(c, "AVAILABLE")
                  if st != "RADAR":
                      allowed.append(c)
              for c, st in self.state.items():
                  if st == "AVAILABLE" and c not in allowed:
                      allowed.append(c)
              return allowed


      class KalmanLayer:
          def __init__(self, Q=0.01, R=0.1):
              self.x = None; self.P = 1.0; self.Q = Q; self.R = R
          def update(self, z):
              z = float(z)
              if self.x is None:
                  self.x = z; return z
              Pp = self.P + self.Q
              K = Pp / (Pp + self.R)
              self.x += K * (z - self.x)
              self.P = (1 - K) * Pp
              return self.x

      class KalmanVector:
          def __init__(self, dim):
              self.k = [KalmanLayer() for _ in range(dim)]
              self.dim = dim
              self._buf = np.empty(dim, dtype=float)
          def update(self, v):
              for i in range(self.dim):
                  self._buf[i] = self.k[i].update(v[i])
              return self._buf

      class KalmanUCB:
          def __init__(self, K, beta=2.5):
              self.K = max(1, int(K))
              self.beta = float(beta)
              self.mu = np.zeros(self.K)
              self.P = np.ones(self.K)
              self.Q = 0.01; self.R = 0.1
          def select(self, allowed):
              if not allowed:
                  return int(np.random.randint(0, self.K))
              allowed_valid = [int(a) for a in allowed if 0 <= int(a) < self.K]
              if not allowed_valid:
                  return int(np.random.randint(0, self.K))
              mu = self.mu; P = self.P; beta = self.beta
              ucbs = {a: mu[a] + beta * math.sqrt(max(0.0, P[a])) for a in allowed_valid}
              m = max(ucbs.values()); best = [k for k, v in ucbs.items() if v == m]
              return int(np.random.choice(best))
          def update(self, arm, reward):
              arm = int(arm)
              if arm < 0 or arm >= self.K:
                  return
              Pp = self.P[arm] + self.Q
              K = Pp / (Pp + self.R)
              self.mu[arm] += K * (float(reward) - self.mu[arm])
              self.P[arm] = (1 - K) * Pp

      def map_14_to_5(f):
          arr = np.asarray(f, dtype=float)
          if arr.size < 14:
              tmp = np.zeros(14, dtype=float); tmp[:arr.size] = arr; arr = tmp
          med = float(arr[0]); rms = float(arr[2])
          snr = max(0.0, rms / (med + 1e-12) - 1.0)
          snr_log = math.log(1.0 + snr)
          return np.array([med, snr_log, float(arr[13]), float(arr[11]), float(arr[12])], dtype=float)


      # ---------------- MAB controller with guarded model load and valid work() ----------------

      class MAB_Controller(gr.sync_block):
          def __init__(self, model_path="", hop_delay=0.5, parent=None, gc_interval: int = 50):
              gr.sync_block.__init__(
                  self,
                  name="MAB_Controller_FullIntegrated",
                  in_sig=[(np.float32, 14)],
                  out_sig=[np.complex64, np.float32, np.float32, np.float32]
              )

              # lightweight, import-time safe initial state
              self.parent = parent
              self.hop_delay = float(hop_delay)
              self._gc_interval = max(1, int(gc_interval))
              self._mem_tick = 0

              # parent introspection safely
              try: nd24 = list(parent.NON_DFS_2_4_GHz)
              except Exception: nd24 = []
              try: nd5 = list(parent.NON_DFS_5_GHz)
              except Exception: nd5 = []
              try: dfs_keys = sorted(map(int, parent.DFS_State.keys()))
              except Exception: dfs_keys = []

              self.arm_to_ch = list(nd24) + list(nd5) + list(dfs_keys)
              self.K = max(1, len(self.arm_to_ch))
              self.ch_to_arm = {ch: i for i, ch in enumerate(self.arm_to_ch)}

              self.dfs = DFSManagerFull(dfs_keys)
              self.ucb = KalmanUCB(self.K)
              self.kf_scalar = [KalmanLayer() for _ in range(self.K)]
              self.kf_feat = [KalmanVector(5) for _ in range(self.K)]

              # guarded model load: try pickle; don't raise on failure
              self.rbn = None
              if isinstance(model_path, str) and model_path.strip():
                  try:
                      with open(model_path, "rb") as fh:
                          try:
                              self.rbn = pickle.load(fh)
                              print("[MAB] Loaded model (pickle):", model_path, flush=True)
                          except Exception as e_pickle:
                              # don't fail import; attempt dill/cloudpickle if available
                              print("[MAB] pickle load error — will try dill/cloudpickle:", str(e_pickle), flush=True)
                              try:
                                  fh.seek(0)
                                  import dill as _dill
                                  self.rbn = _dill.load(fh)
                                  print("[MAB] Loaded model (dill):", model_path, flush=True)
                              except Exception as e_dill:
                                  print("[MAB] model load failed, continuing without rbn:", str(e_dill), flush=True)
                  except Exception as e_open:
                      print("[MAB] Could not open model file — continuing without rbn:", str(e_open), flush=True)

              # runtime vars
              self.oracle = 0.0
              self.init_sweep = True
              self.sweep = 0

          def predict_reward(self, feat, arm):
              try:
                  arm = int(arm)
                  if arm < 0 or arm >= self.K:
                      arm = 0
                  x = map_14_to_5(feat)
                  xs = self.kf_feat[arm].update(x)
                  if self.rbn is not None:
                      try:
                          v = self.rbn(xs.reshape(1, -1))
                          out = float(np.asarray(v).reshape(-1)[0])
                          del v
                          return out
                      except Exception:
                          pass
                  return float(1.0 / (1.0 + abs(xs[0])))
              except Exception as e:
                  print("[MAB] predict_reward internal error; fallback used:", str(e), flush=True)
                  return 0.0

          def work(self, input_items, output_items):
              import traceback
              try:
                  # quick guard: no input
                  if not input_items or len(input_items[0]) == 0:
                      # heartbeat so we know thread is alive even with no input
                      self._hb = getattr(self, "_hb", 0) + 1
                      if (self._hb % 1000) == 0:
                          print(f"[MAB] heartbeat (no input) tick={self._hb}", flush=True)
                      return 0

                  inbuf = input_items[0]
                  out_ch = output_items[0]
                  out_rew = output_items[1]
                  out_orc = output_items[2]
                  out_reg = output_items[3]

                  n_avail = len(inbuf)
                  n_space = min(len(out_ch), len(out_rew), len(out_orc), len(out_reg))
                  m = min(n_avail, n_space)

                  # if no space, show debug and return
                  if m == 0:
                      self._starve = getattr(self, "_starve", 0) + 1
                      if (self._starve % 200) == 0:
                          print(f"[MAB] no output space (n_avail={n_avail}, n_space={n_space})", flush=True)
                      return 0

                  # periodic debug message
                  self._calls = getattr(self, "_calls", 0) + 1
                  if (self._calls % 200) == 0:
                      print(f"[MAB] work called: n_avail={n_avail}, n_space={n_space}, processing m={m}", flush=True)

                  ch_to_arm = self.ch_to_arm
                  arm_to_ch = self.arm_to_ch

                  for i in range(m):
                      feat = inbuf[i]

                      # DFS + allowed arms
                      self.dfs.step()
                      allowed_ch = self.dfs.filter_sense_log(arm_to_ch)
                      allowed_arms = [ch_to_arm[c] for c in allowed_ch if c in ch_to_arm]

                      # Arm selection (existing sweep logic preserved)
                      if self.init_sweep and self.sweep < self.K and self.sweep < len(arm_to_ch):
                          arm = self.sweep
                          self.sweep += 1
                          if self.sweep >= self.K:
                              self.init_sweep = False
                      else:
                          arm = self.ucb.select(allowed_arms)

                      arm = int(arm)
                      if arm < 0 or arm >= self.K:
                          arm = 0

                      next_ch = int(arm_to_ch[arm]) if 0 <= arm < len(arm_to_ch) else (int(arm_to_ch[0]) if arm_to_ch else 0)

                      try:
                          self.parent.current_ch = next_ch
                      except Exception:
                          pass

                      rew = self.predict_reward(feat, arm)
                      if rew > self.oracle:
                          self.oracle = rew
                      regret = self.oracle - rew
                      r_ucb = -regret

                      rs = self.kf_scalar[arm].update(r_ucb)
                      self.ucb.update(arm, rs)

                      # Logging
                      try:
                          print(json.dumps({
                              "next_channel": int(next_ch),
                              "reward": float(rew),
                              "oracle": float(self.oracle),
                              "regret": float(regret),
                              "dfs_state": self.dfs.state
                          }), flush=True)
                      except Exception:
                          print("next_ch", next_ch, "rew", rew, "oracle", self.oracle, "regret", regret, flush=True)

                      # Safe writes (we ensured m <= output sizes)
                      out_ch[i] = np.complex64(complex(next_ch, 0))
                      out_rew[i] = np.float32(rew)
                      out_orc[i] = np.float32(self.oracle)
                      out_reg[i] = np.float32(regret)

                      # update per-sample DFS
                      self.dfs.step()

                      # free transient references
                      del feat, rs, r_ucb

                  # occasional GC
                  self._mem_tick = getattr(self, "_mem_tick", 0) + 1
                  if (self._mem_tick % getattr(self, "_gc_interval", 50)) == 0:
                      import gc; gc.collect()

                  return m

              except Exception:
                  print("[MAB] Exception in work():", flush=True)
                  traceback.print_exc()
                  return 0
    gc_interval: '50'
    hop_delay: '0.005'
    model_path: '''rbn_predictor_kalmanucb_optimized.pkl'''
    parent: None
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from PIL import Image
      from gnuradio import gr

      IMG_IN  = 255 * 255  # 65025
      IMG_OUT = 224 * 224  # 50176

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="VecResize_255_to_224",
                  in_sig=[(np.uint8, IMG_IN)],   # 65025 input
                  out_sig=[(np.uint8, IMG_OUT)]  # 50176 output
              )

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              # Convert incoming vector to 255×255 image
              img = Image.fromarray(inp.reshape(255, 255)).convert("RGB")

              # Resize to 224×224
              img = img.resize((224, 224))

              # Convert back to 1D vector
              out[:] = np.asarray(img, dtype=np.uint8).transpose(2,0,1)[0].reshape(IMG_OUT)

              # Return number of input samples consumed
              return IMG_IN  # 👈 Correct return ✅
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from collections import deque

      class blk(gr.sync_block):
          """
          Raw-signal interference power estimator.
          Input:  complex64 IQ samples
          Output: float32 per-sample interference power (Pi)

          Pi = ShortTermPower - NoiseFloor
          """

          def __init__(self,
                       short_win=256,      # short-term energy window
                       noise_win=4096,     # long-term noise estimator window
                       alpha=0.05):        # smoothing factor
              gr.sync_block.__init__(
                  self,
                  name='RAW_InterferenceEstimator',
                  in_sig=[np.complex64],
                  out_sig=[np.float32]
              )

              # Parameters
              self.short_win = int(short_win)
              self.noise_win = int(noise_win)
              self.alpha = float(alpha)

              # Buffers
              self.short_buf = deque(maxlen=self.short_win)
              self.noise_buf = deque(maxlen=self.noise_win)

              # State variables
              self.noise_floor = 0.0
              self.last_Pi = 0.0

          def work(self, input_items, output_items):
              iq = input_items[0]
              out = output_items[0]
              n = len(iq)

              for i in range(n):
                  s = iq[i]

                  # instantaneous magnitude squared
                  p_inst = float((s.real * s.real) + (s.imag * s.imag))

                  # short-term window power
                  self.short_buf.append(p_inst)
                  Pshort = float(np.mean(self.short_buf)) if len(self.short_buf) > 1 else p_inst

                  # update long-term noise estimate (slow varying)
                  self.noise_buf.append(p_inst)
                  Pnoise_raw = float(np.median(self.noise_buf))

                  # EMA smoothing noise floor
                  self.noise_floor = (1 - self.alpha) * self.noise_floor + self.alpha * Pnoise_raw

                  # Interference power
                  Pi = Pshort - self.noise_floor
                  if Pi < 0:        # clamp numerical negatives
                      Pi = 0.0

                  self.last_Pi = Pi
                  out[i] = Pi

              return n
    alpha: '0.3'
    noise_win: '4096'
    short_win: '256'
  states: {}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # sample_probe_vector.py
      import time, numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Vector probe: use when downstream sees vectors (e.g. stream_to_vector).
          in_sig = [(np.complex64, N)] and out_sig same. Reports vector count.
          Set report_every to a small number for fast feedback (e.g. 10).
          """
          def __init__(self, vec_len=2048, report_every=10):
              # vec_len is the number of samples per vector element
              gr.sync_block.__init__(self,
                  name="sample_probe_vector",
                  in_sig=[(np.complex64, int(vec_len))],
                  out_sig=[])
              self.vec_len = int(vec_len)
              self.count = 0
              self.report_every = int(report_every)
              

          def work(self, input_items, output_items):
              inbuf = input_items[0]
              nvec = len(inbuf)   # number of vectors available
              if nvec > 0:
                  self.count += nvec
                  # copy vectors through
                  
                  if self.count % self.report_every == 0 or self.count < 5:
                      print(f"[vector-probe] vectors={self.count} vec_len={self.vec_len} time={time.time():.1f}", flush=True)
              else:
                  print("[vector-probe] no vectors this call", flush=True)
              return nvec
    report_every: '10'
    vec_len: '2048'
  states: {state: disabled}
- name: epy_block_8
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Smooth Stream → Vector Accumulator
          ----------------------------------
          Eliminates GR scheduler batching.

          - Accepts a raw stream of complex64 samples
          - Maintains an internal buffer
          - Emits vectors of length vec_len as soon as enough samples arrive
          - Never stalls upstream or downstream
          """

          def __init__(self, vec_len=2048):
              gr.sync_block.__init__(
                  self,
                  name="smooth_stream_to_vector",
                  in_sig=[np.complex64],
                  out_sig=[(np.complex64, vec_len)]
              )

              self.vec_len = vec_len
              self.buffer = np.zeros(0, dtype=np.complex64)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              nin = len(inp)
              nout = len(out)

              # append new samples to buffer
              if nin > 0:
                  self.buffer = np.concatenate((self.buffer, inp))

              produced = 0

              # output as many full vectors as available
              while len(self.buffer) >= self.vec_len and produced < nout:
                  out[produced][:] = self.buffer[:self.vec_len]
                  self.buffer = self.buffer[self.vec_len:]
                  produced += 1

              return produced
    vec_len: '200'
  states: {state: disabled}
- name: epy_block_9
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[
                      np.uint8,          # 0: change_flag
                      np.float32,        # 1: duty_cycle
                      np.complex64,      # 2: next_channel (real)
                      (np.int16, 6),     # 3: interference vector
                      np.float32,        # 4: reward
                      np.float32,        # 5: oracle
                      np.float32,        # 6: regret
                      np.complex64,      # 7: est_center + j*bandwidth
                      np.float32,        # 8: confidence
                      np.float32         # 9: interference_power
                  ],
                  out_sig=[     # 1: duty_cycle
                      ]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = 1
              return 1
    example_param: '1.0'
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '5.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: Center_freq
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: Center_freq
    gain1: '''slow_attack'''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: Center_freq
    fftsize: '1024'
    name: '"Trnasmitted"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: Center_freq
    fftsize: '1024'
    name: '"Recieved"'
    type: complex
    update_time: '0.1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: A
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: B
  states: {state: disabled}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: C
  states: {state: disabled}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: E
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: D
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_2, '0']
- [blocks_stream_to_vector_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_7, '0']
- [epy_block_0, '0', epy_block_4_0_0, '0']
- [epy_block_0, '1', epy_block_5, '0']
- [epy_block_1, '0', blocks_add_xx_0, '0']
- [epy_block_2, '0', epy_block_3, '0']
- [epy_block_3, '0', epy_block_4_0, '0']
- [epy_block_3, '0', epy_block_9, '0']
- [epy_block_3, '0', virtual_sink_0, '0']
- [epy_block_3, '1', epy_block_4_0, '1']
- [epy_block_3, '1', epy_block_9, '1']
- [epy_block_3, '1', virtual_sink_0_1, '0']
- [epy_block_4, '0', epy_block_4_0, '3']
- [epy_block_4, '0', epy_block_9, '3']
- [epy_block_4, '1', epy_block_4_0, '7']
- [epy_block_4, '1', epy_block_9, '7']
- [epy_block_4, '1', virtual_sink_0_0_0, '0']
- [epy_block_4, '2', epy_block_4_0, '8']
- [epy_block_4, '2', epy_block_9, '8']
- [epy_block_4_0_0, '0', epy_block_4_0, '2']
- [epy_block_4_0_0, '0', epy_block_9, '2']
- [epy_block_4_0_0, '0', virtual_sink_0_0, '0']
- [epy_block_4_0_0, '1', epy_block_4_0, '4']
- [epy_block_4_0_0, '1', epy_block_9, '4']
- [epy_block_4_0_0, '2', epy_block_4_0, '5']
- [epy_block_4_0_0, '2', epy_block_9, '5']
- [epy_block_4_0_0, '3', epy_block_4_0, '6']
- [epy_block_4_0_0, '3', epy_block_9, '6']
- [epy_block_5, '0', epy_block_4, '0']
- [epy_block_6, '0', epy_block_4_0, '9']
- [epy_block_6, '0', epy_block_9, '9']
- [epy_block_6, '0', virtual_sink_0_0_0_0, '0']
- [epy_block_8, '0', blocks_complex_to_mag_squared_0, '0']
- [epy_block_8, '0', epy_block_0, '0']
- [epy_block_8, '0', epy_block_7, '0']
- [iio_pluto_source_0, '0', blocks_stream_to_vector_0, '0']
- [iio_pluto_source_0, '0', epy_block_6, '0']
- [iio_pluto_source_0, '0', epy_block_8, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
