options:
  parameters:
    generate_options: qt_gui
    id: Interference
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Injection_Frequency
  id: variable
  parameters:
    value: int(2.44e9)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"Realistic Microwave Oven Interference - Dynamic FFT Shaping v4\"\"\"\n\n    def __init__(self,\n                 samp_rate=1e6,\n                 burst_rate=100,\n                 duty_cycle=0.40,\n                 noise_amp=1.0,\n                 wobble_freq=3.0,\n                 wobble_depth=0.12,\n                 hump_width=0.55,     # <<< STRONG microwave-like width\n                 hump_gain=15.0):     # <<< STRONG microwave-like intensity\n\n        gr.sync_block.__init__(\n            self,\n            name='Microwave Oven (FFT-Shaped Dynamic v4)',\n            in_sig=None,\n            out_sig=[np.complex64]\n        )\n\n        # Store parameters\n        self.samp_rate = samp_rate\n        self.burst_rate = burst_rate\n        self.duty_cycle = duty_cycle\n        self.noise_amp = noise_amp\n        self.wobble_freq = wobble_freq\n        self.wobble_depth = wobble_depth\n        self.hump_width = hump_width\n        self.hump_gain = hump_gain\n\n        # Burst timing\n        self.samples_per_period = int(samp_rate / burst_rate)\n        self.samples_on = int(self.samples_per_period * duty_cycle)\n        self.counter = 0\n        self.time_idx = 0\n        self.phase = 0\n\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = len(out)\n\n        # Time vector\n        t = (np.arange(n) + self.time_idx) / self.samp_rate\n\n        # 1 — Base noise (complex)\n        noise = (np.random.normal(0, self.noise_amp, n) +\n                 1j*np.random.normal(0, self.noise_amp, n))\n\n        # 2 — FFT-shaping (dynamic, based on buffer size)\n        F = np.fft.fftshift(np.fft.fft(noise))\n\n        # Frequency axis for shaping curve\n        freqs = np.linspace(-1, 1, n)\n\n        # Microwave hump (Gaussian bell shape across spectrum)\n        shape = 1 + self.hump_gain * np.exp(-(freqs / self.hump_width)**2)\n\n        # 3 — Add MANY cavity-mode spikes (microwave textures)\n        spikes = np.zeros(n)\n        for _ in range(120):     # <<< Increased for realism\n            pos = np.random.randint(0, n)\n            spikes[pos] = np.random.uniform(0.4, 1.0)\n\n        # Smooth the spikes (spread them a little)\n        spikes = np.convolve(spikes, np.hanning(61), mode=\"same\")\n\n        # Combine with hump\n        shape += spikes\n\n        # Apply shaping window\n        F *= shape\n\n        # Back to time-domain\n        shaped = np.fft.ifft(np.fft.ifftshift(F))\n\n        # 4 — Magnetron wobble (cause center drift)\n        wobble = self.wobble_depth * np.sin(2*np.pi*self.wobble_freq * t)\n        phase_drift = np.cumsum(2*np.pi * wobble)\n        shaped *= np.exp(1j * phase_drift)\n\n        # 5 — Burst gating\n        for i in range(n):\n            if self.counter < self.samples_on:\n                out[i] = np.complex64(shaped[i])\n            else:\n                out[i] = 0\n\n            self.counter += 1\n            if self.counter >= self.samples_per_period:\n                self.counter = 0\n\n        # Update time\n        self.time_idx += n\n        return n\n\n"
    burst_rate: '100'
    duty_cycle: '0.3'
    hump_gain: '3.0'
    hump_width: '0.35'
    noise_amp: '0.8'
    samp_rate: samp_rate
    wobble_depth: '0.15'
    wobble_freq: '2.0'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"Continuous ZigBee-like interference for 4 MHz sample rate\"\"\"\n\n    def __init__(self,\n                 samp_rate=4e6,        # Works with 4 MHz\n                 center_freq=2.44e9,   # ZigBee Ch.18\n                 chip_rate=2e6,        # ZigBee chips\n                 gain=0.8):            # Interference power\n\n        gr.sync_block.__init__(\n            self,\n            name='ZigBee Interference (Continuous)',\n            in_sig=None,\n            out_sig=[np.complex64]\n        )\n\n        self.samp_rate = samp_rate\n        self.center_freq = center_freq\n        self.chip_rate = chip_rate\n        self.gain = gain\n\n        # ZigBee 32-chip sequence (one example)\n        self.sequence = np.array(\n            [1,1,1,-1,1,1,-1,1,1,-1,-1,-1,-1, 1,-1, 1, 1,1,-1,-1,\n             1,-1,-1, 1,-1, 1,-1,-1,-1, 1,1,1]\n        )\n\n        # samples per chip ( = 2 at 4MHz SR)\n        self.sps = max(1, int(self.samp_rate / self.chip_rate))\n\n        # pre-generate continuous baseband chipstream\n        self.offset = 0\n\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = len(out)\n\n        # Repeat chips enough times to fill n samples\n        repeated = np.repeat(self.sequence, self.sps)\n\n        # Continuous wraparound indexing\n        data = np.zeros(n, dtype=np.complex64)\n        for i in range(n):\n            idx = (self.offset + i) % len(repeated)\n            data[i] = repeated[idx]\n\n        self.offset = (self.offset + n) % len(repeated)\n\n        # random Q-phase (simple OQPSK-like)\n        phase = np.exp(1j * np.pi * (np.random.rand() * 2 - 1))\n\n        out[:] = (data * phase * self.gain).astype(np.complex64)\n        return n\n\t\n"
    center_freq: int(2.44e9)
    chip_rate: '2000000.0'
    gain: '1.0'
    samp_rate: int(samp_rate)
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"BLE Burst FHSS Interference Generator (with full default values)\"\"\"\n\n    def __init__(self,\n                 samp_rate=4e6,       # Default: 4 MHz (works perfectly on PlutoSDR)\n                 ble_bw=1e6,          # Default BLE channel width\n                 hop_rate=1600,       # Default BLE hop rate (1600 hops/sec)\n                 burst_ms=4,          # Default burst length = 4 ms\n                 gain=0.8):           # Default interference strength\n\n        gr.sync_block.__init__(\n            self,\n            name='BLE FHSS Burst Interference',\n            in_sig=None,\n            out_sig=[np.complex64]\n        )\n\n        # Save defaults\n        self.samp_rate = samp_rate\n        self.ble_bw = ble_bw\n        self.hop_rate = hop_rate\n        self.burst_ms = burst_ms\n        self.gain = gain\n\n        # Compute burst length in samples\n        self.burst_len = int((burst_ms / 1000.0) * samp_rate)\n\n        # Normalize BLE hopping positions (40 BLE channels across spectrum)\n        self.channels = np.linspace(-0.5, 0.5, 40)\n\n        self.t = 0                 # time index\n        self.current_channel = 0   # current BLE hop index\n\n\n    def _make_ble_mask(self, n, channel_pos):\n        \"\"\"Create BLE GFSK-like 1 MHz spectral mask centered at channel_pos.\"\"\"\n        freqs = np.linspace(-0.5, 0.5, n)\n        bw_norm = self.ble_bw / self.samp_rate\n        rolloff = 0.25\n\n        mask = np.zeros(n)\n        for i, f in enumerate(freqs):\n            fshift = abs(f - channel_pos)\n\n            if fshift <= (bw_norm/2)*(1-rolloff):\n                mask[i] = 1.0\n            elif fshift <= (bw_norm/2)*(1+rolloff):\n                x = (fshift - (bw_norm/2)*(1-rolloff)) / (bw_norm*rolloff)\n                mask[i] = 0.5 * (1 + np.cos(np.pi * x))\n\n        return mask\n\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = len(out)\n\n        #\n        # 1) Burst ON/OFF pattern\n        #\n        if (self.t // self.burst_len) % 2 == 0:\n            active = True\n        else:\n            active = False\n\n        #\n        # 2) BLE hopping logic\n        #\n        hop_interval_samples = int(self.samp_rate / self.hop_rate)\n        if hop_interval_samples < 1:\n            hop_interval_samples = 1\n\n        if self.t % hop_interval_samples == 0:\n            self.current_channel = np.random.randint(0, 40)\n\n        #\n        # 3) Generate white noise base\n        #\n        noise = (np.random.normal(0, 1, n) +\n                 1j * np.random.normal(0, 1, n))\n\n        #\n        # 4) If burst active → shape interference into BLE channel\n        #\n        if active:\n            F = np.fft.fftshift(np.fft.fft(noise))\n\n            channel_pos = self.channels[self.current_channel]\n            mask = self._make_ble_mask(n, channel_pos) * self.gain\n\n            F *= mask\n            shaped = np.fft.ifft(np.fft.ifftshift(F))\n        else:\n            shaped = np.zeros(n, dtype=np.complex64)\n\n        out[:] = shaped.astype(np.complex64)\n        self.t += n\n        return n\n\n"
    ble_bw: '1000000.0'
    burst_ms: '4'
    gain: '0.8'
    hop_rate: '1600'
    samp_rate: '4000000.0'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"\n    Multi-FHSS Interference Generator (Simulation Only)\n    - Works with QT sinks for visualization\n    - All defaults handled internally\n    \"\"\"\n\n    def __init__(self,\n                 samp_rate=4e6,        # Default: 4 MHz\n                 num_hoppers=5,        # Default: 5 FHSS devices\n                 hop_rate=1000,        # Default: 1000 hops/sec\n                 num_channels=40,      # Default: 40 channels\n                 tone_bw=300e3,        # Default: 300 kHz spike width\n                 gain=1.0):            # Default: amplitude\n\n        gr.sync_block.__init__(\n            self,\n            name='Multi-FHSS Interference (Default)',\n            in_sig=None,\n            out_sig=[np.complex64]\n        )\n\n        # Store defaults\n        self.samp_rate = samp_rate\n        self.num_hoppers = num_hoppers\n        self.hop_rate = hop_rate\n        self.num_channels = num_channels\n        self.tone_bw = tone_bw\n        self.gain = gain\n\n        # Hop interval in samples\n        self.hop_interval = max(1, int(self.samp_rate / self.hop_rate))\n\n        # FHSS channel positions normalized (-0.5 to +0.5)\n        self.channels = np.linspace(-0.5, 0.5, self.num_channels)\n\n        # Per-hopper random states\n        self.current_channel = np.random.randint(0, self.num_channels, self.num_hoppers)\n        self.t = 0\n\n\n    def _make_mask(self, nfft, pos):\n        \"\"\"Gaussian spike mask at normalized channel position 'pos'\"\"\"\n        f = np.linspace(-0.5, 0.5, nfft)\n        bw = self.tone_bw / self.samp_rate\n        sigma = bw / 3\n        return np.exp(-0.5 * ((f - pos) / sigma) ** 2)\n\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = len(out)\n\n        result = np.zeros(n, dtype=np.complex64)\n\n        # Generate interference from each FHSS device\n        for h in range(self.num_hoppers):\n\n            # Hop on boundary\n            if self.t % self.hop_interval == 0:\n                self.current_channel[h] = np.random.randint(0, self.num_channels)\n\n            # Base noise\n            noise = (np.random.normal(0, 1, n) +\n                     1j * np.random.normal(0, 1, n))\n\n            # Frequency shaping\n            F = np.fft.fftshift(np.fft.fft(noise))\n            mask = self._make_mask(n, self.channels[self.current_channel[h]])\n            F *= mask * self.gain\n            shaped = np.fft.ifft(np.fft.ifftshift(F))\n\n            result += shaped\n\n        # Normalize\n        m = np.max(np.abs(result))\n        if m > 0:\n            result /= m\n\n        out[:] = result.astype(np.complex64)\n        self.t += n\n        return n\n\n"
    gain: '1.0'
    hop_rate: '800'
    num_channels: '40'
    num_hoppers: '5'
    samp_rate: '4000000.0'
    tone_bw: '300000'
  states: {state: disabled}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"\n    Realistic DFS Radar Signal (Type-1)\n    Simulation-only radar pulses for visualization in QT sinks.\n    DEFAULT PARAMETERS IMPLEMENT FCC/ETSI DFS RADAR TYPE-1.\n    \"\"\"\n\n    def __init__(self,\n                 samp_rate=20e6,          # 20 MHz required for 1 µs resolution\n                 pulse_width_us=1.0,      # Pulse width (1 µs)\n                 pulses_per_burst=9,      # DFS Type 1 = 9 pulses\n                 pri_us=1428.0,           # Pulse Repetition Interval (1428 µs)\n                 burst_interval_ms=1000,  # One burst every 1 second\n                 radar_bw=3e6,            # ~3 MHz radar bandwidth\n                 gain=1.0):               # amplitude\n        gr.sync_block.__init__(\n            self,\n            name='DFS Radar (Type-1)',\n            in_sig=None,\n            out_sig=[np.complex64]\n        )\n\n        # Save defaults\n        self.samp_rate = samp_rate\n        self.pulse_width = int((pulse_width_us / 1e6) * samp_rate)\n        self.pulses_per_burst = pulses_per_burst\n        self.pri = int((pri_us / 1e6) * samp_rate)\n        self.burst_interval = int((burst_interval_ms / 1000.0) * samp_rate)\n        self.radar_bw = radar_bw\n        self.gain = gain\n\n        # Internal time index\n        self.t = 0\n\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = len(out)\n\n        # Output buffer\n        radar = np.zeros(n, dtype=np.complex64)\n\n        # Local time vector\n        t_local = np.arange(n)\n\n        # Current time inside repeating burst cycle\n        cycle_pos = (self.t + t_local) % self.burst_interval\n\n        # For each pulse in the burst\n        for p in range(self.pulses_per_burst):\n            # Pulse start time in samples\n            pulse_start = p * self.pri\n            pulse_end = pulse_start + self.pulse_width\n\n            # Boolean mask for pulse presence\n            pulse_mask = np.logical_and(cycle_pos >= pulse_start,\n                                        cycle_pos < pulse_end)\n\n            # Radar pulse = complex amplitude (carrier is baseband)\n            radar[pulse_mask] = self.gain + 0j\n\n        # BANDWIDTH SHAPING (Radar ≈ 3 MHz)\n        if self.radar_bw > 0:\n            # Create colored noise\n            noise = (np.random.normal(0, 0.05, n) +\n                     1j * np.random.normal(0, 0.05, n)).astype(np.complex64)\n\n            # Shape noise with Gaussian spectral mask\n            freqs = np.linspace(-self.samp_rate/2, self.samp_rate/2, n)\n            mask = np.exp(-0.5 * (freqs / (self.radar_bw/2))**2)\n\n            F = np.fft.fftshift(np.fft.fft(noise))\n            F *= mask\n            shaped_noise = np.fft.ifft(np.fft.ifftshift(F))\n\n            radar += shaped_noise.astype(np.complex64)\n\n        # Write output\n        out[:] = radar\n        self.t += n\n        return n\n\n"
    burst_interval_ms: '1000'
    gain: '3.0'
    pri_us: '1428.0'
    pulse_width_us: '1.0'
    pulses_per_burst: '9'
    radar_bw: '3000000.0'
    samp_rate: '20000000.0'
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"\n    Realistic DFS Radar Type-2 (FCC / ETSI Standard)\n    - Pulse width: 5 us\n    - PRI: 200 us\n    - Pulses per burst: 10\n    - Burst interval: 250 ms\n    - Bandwidth ~6 MHz\n    \"\"\"\n\n    def __init__(self,\n                 samp_rate=20e6,          # 20 MHz required for 5 us pulse shaping\n                 center_freq=5260e6,      # visual center frequency\n                 pulse_width_us=5.0,      # DFS Type-2 official value: 5 us\n                 pri_us=200.0,            # PRI = 200 us\n                 pulses_per_burst=10,     # Type-2: 8–20; default = 10\n                 burst_interval_ms=250,   # DFS standard: 250 ms burst interval\n                 radar_bw=6e6,            # ~6 MHz radar spectral width\n                 amplitude=1.0,           # pulse amplitude\n                 phase_mod=True):         # phase jitter for realism\n\n        gr.sync_block.__init__(\n            self,\n            name='DFS Radar Type-2 (Realistic Default)',\n            in_sig=None,\n            out_sig=[np.complex64]\n        )\n\n        self.samp_rate = float(samp_rate)\n        self.center_freq = float(center_freq)\n        self.pulse_width = max(1, int((pulse_width_us / 1e6) * self.samp_rate))\n        self.pulses_per_burst = int(pulses_per_burst)\n        self.pri = max(1, int((pri_us / 1e6) * self.samp_rate))\n        self.burst_interval = max(1, int((burst_interval_ms / 1000.0) * self.samp_rate))\n        self.radar_bw = float(radar_bw)\n        self.amplitude = float(amplitude)\n        self.phase_mod = bool(phase_mod)\n\n        self.t = 0  # time counter\n\n    def _make_pulse(self, length):\n        \"\"\"Generate a realistic 5-us radar pulse with FM jitter and shaping.\"\"\"\n        win = np.hanning(length * 2)[0:length]\n        tvec = np.arange(length) / self.samp_rate\n\n        # Tiny chirp inside pulse\n        chirp_bw = self.radar_bw * 0.15  # small fraction of radar BW\n        k = chirp_bw / (length / self.samp_rate)\n        phase = 2*np.pi * (0.5 * k * tvec**2)\n\n        if self.phase_mod:\n            phase += np.random.randn(length) * 0.02\n\n        pulse = (self.amplitude * win) * np.exp(1j * phase)\n\n        return pulse.astype(np.complex64)\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = len(out)\n        buf = np.zeros(n, dtype=np.complex64)\n\n        t_local = self.t + np.arange(n)\n        cycle_pos = t_local % self.burst_interval\n\n        for p in range(self.pulses_per_burst):\n            start = p * self.pri\n            end = start + self.pulse_width\n\n            mask = np.logical_and(cycle_pos >= start, cycle_pos < end)\n            if not np.any(mask):\n                continue\n\n            pulse = self._make_pulse(self.pulse_width)\n            idx = np.where(mask)[0]\n            pos = (cycle_pos[idx] - start).astype(int)\n            buf[idx] += pulse[pos]\n\n        # add light clutter noise (band-limited)\n        noise = (np.random.normal(0, 0.005, n) +\n                 1j * np.random.normal(0, 0.005, n))\n\n        F = np.fft.fftshift(np.fft.fft(noise))\n        freqs = np.linspace(-0.5, 0.5, n, endpoint=False) * self.samp_rate\n        sigma = self.radar_bw / 2\n        mask = np.exp(-0.5 * (freqs / sigma)**2)\n        F *= mask\n        clutter = np.fft.ifft(np.fft.ifftshift(F))\n\n        buf += 0.05 * clutter.astype(np.complex64)\n\n        out[:] = buf\n        self.t += n\n        return n\n\n"
    amplitude: '1.0'
    burst_interval_ms: '250'
    center_freq: '5260000000.0'
    phase_mod: 'True'
    pri_us: '200.0'
    pulse_width_us: '5.0'
    pulses_per_burst: '10'
    radar_bw: '6000000.0'
    samp_rate: '20000000.0'
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"\n    DFS Radar Combo (Type-1 + Type-2)\n    REALISTIC DEFAULT VALUES (FCC/ETSI)\n    - Alternates Type-1 and Type-2 radar every 1 second\n    - Type-1: 1us PW, 9 pulses, 1428us PRI, 1s interval\n    - Type-2: 5us PW, 10 pulses, 200us PRI, 250ms interval\n    - Simulation-only, safe for QT sinks\n    \"\"\"\n\n    def __init__(self,\n                 samp_rate=20e6,             # REQUIRED for microsecond pulses\n                 switch_interval_s=1.0,      # switch radar mode every 1 second\n\n                 # ---------- TYPE 1 DEFAULTS ----------\n                 t1_pulse_width_us=1.0,      # 1 µs\n                 t1_pulses_per_burst=9,      # 9 pulses\n                 t1_pri_us=1428.0,           # 1428 µs PRI\n                 t1_burst_interval_ms=1000,  # burst every 1 sec\n                 t1_bw=3e6,                  # 3 MHz radar BW\n\n                 # ---------- TYPE 2 DEFAULTS ----------\n                 t2_pulse_width_us=5.0,      # 5 µs\n                 t2_pulses_per_burst=10,     # 10 pulses\n                 t2_pri_us=200.0,            # 200 µs PRI\n                 t2_burst_interval_ms=250,   # burst every 0.25 sec\n                 t2_bw=6e6,                  # 6 MHz radar BW\n\n                 amplitude=1.0):              # default power\n        gr.sync_block.__init__(\n            self,\n            name='DFS Radar Combo (Type1+Type2)',\n            in_sig=None,\n            out_sig=[np.complex64]\n        )\n\n        self.samp_rate = float(samp_rate)\n        self.switch_interval = int(samp_rate * switch_interval_s)\n        self.amplitude = float(amplitude)\n\n        # Store Type-1 parameters\n        self.t1_pw = int((t1_pulse_width_us/1e6)*samp_rate)\n        self.t1_ppb = int(t1_pulses_per_burst)\n        self.t1_pri = int((t1_pri_us/1e6)*samp_rate)\n        self.t1_burst = int((t1_burst_interval_ms/1000.0)*samp_rate)\n        self.t1_bw = float(t1_bw)\n\n        # Store Type-2 parameters\n        self.t2_pw = int((t2_pulse_width_us/1e6)*samp_rate)\n        self.t2_ppb = int(t2_pulses_per_burst)\n        self.t2_pri = int((t2_pri_us/1e6)*samp_rate)\n        self.t2_burst = int((t2_burst_interval_ms/1000.0)*samp_rate)\n        self.t2_bw = float(t2_bw)\n\n        self.t = 0  # internal time counter\n\n    # --------------------------------------------------------------------\n    def _make_pulse(self, length, bw):\n        \"\"\"Generate a shaped radar pulse with small chirp.\"\"\"\n        win = np.hanning(length*2)[0:length]\n        tvec = np.arange(length) / self.samp_rate\n\n        # small chirp for realism\n        chirp_bw = bw * 0.1\n        k = chirp_bw / (length / self.samp_rate)\n        phase = 2*np.pi * (0.5*k*tvec*tvec)\n\n        pulse = (self.amplitude * win) * np.exp(1j*phase)\n\n        # tiny noise for realism\n        pulse += (np.random.randn(length)*0.01 + 1j*np.random.randn(length)*0.01)\n\n        return pulse.astype(np.complex64)\n\n    # --------------------------------------------------------------------\n    def _place_radar(self, buf, t_local, pw, ppb, pri, burst_interval, bw):\n        \"\"\"Place burst pulses into the buffer for one radar type.\"\"\"\n        cycle_pos = t_local % burst_interval\n        template = self._make_pulse(pw, bw)\n\n        for p in range(ppb):\n            start = p * pri\n            end = start + pw\n\n            mask = np.logical_and(cycle_pos >= start, cycle_pos < end)\n            if not np.any(mask):\n                continue\n\n            idx = np.where(mask)[0]\n            pos = ((cycle_pos[idx]-start).astype(int))\n            pos = np.clip(pos, 0, pw-1)\n\n            buf[idx] += template[pos]\n\n        return buf\n\n    # --------------------------------------------------------------------\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = len(out)\n        t_local = self.t + np.arange(n)\n\n        buf = np.zeros(n, dtype=np.complex64)\n\n        # Decide current mode (Type1 or Type2)\n        mode = (self.t // self.switch_interval) % 2\n\n        if mode == 0:\n            # ---------------- TYPE 1 ACTIVE ----------------\n            buf = self._place_radar(\n                buf, t_local,\n                self.t1_pw, self.t1_ppb,\n                self.t1_pri, self.t1_burst, self.t1_bw\n            )\n        else:\n            # ---------------- TYPE 2 ACTIVE ----------------\n            buf = self._place_radar(\n                buf, t_local,\n                self.t2_pw, self.t2_ppb,\n                self.t2_pri, self.t2_burst, self.t2_bw\n            )\n\n        out[:] = buf\n        self.t += n\n        return n\n\n"
    amplitude: '1.0'
    samp_rate: '20000000.0'
    switch_interval_s: '1.0'
    t1_burst_interval_ms: '1000'
    t1_bw: '3000000.0'
    t1_pri_us: '1428.0'
    t1_pulse_width_us: '1.0'
    t1_pulses_per_burst: '9'
    t2_burst_interval_ms: '250'
    t2_bw: '6000000.0'
    t2_pri_us: '200.0'
    t2_pulse_width_us: '5.0'
    t2_pulses_per_burst: '10'
  states: {}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: |
      """
      Intermittent Interference Injector (3 DFS types) with DFS scheduler + JSONL logging.

      Port mapping (inputs, in order):
        - in0 : complex64  -> ip1 : DFS Type 1
        - in1 : complex64  -> ip2 : DFS Type 2
        - in2 : complex64  -> ip3 : DFS Type 1 + 2
        - in3 : complex64  -> dfs_in : DFS-monitor signal used to detect radar (power measured)

      Output:
        - out  : complex64 combined interference (or zeros when idle/hold-off)

      Logging:
        - Newline-delimited JSON appended to log_path
        - Events: injection_start, injection_terminated_by_dfs, dfs_detected
      """

      import numpy as np
      import json
      import os
      import math
      from datetime import datetime, timezone
      from gnuradio import gr

      # Human-readable labels for the three interference inputs
      INTERFERENCE_MAP = {
          0: "DFS_Type_1",        # in0 / ip1
          1: "DFS_Type_2",        # in1 / ip2
          2: "DFS_Type_1_and_2"   # in2 / ip3
      }


      class blk(gr.sync_block):
          def __init__(self,
                       example_param=1.0,

                       # timing / scheduling
                       sample_rate=20e6,
                       mean_interval_seconds=2.0,
                       inject_duration_seconds=0.1,

                       # pure injection (occasional long single-source injection)
                       pure_inject_enabled=True,
                       pure_injection_probability=0.02,
                       pure_inject_duration_seconds=20.0,

                       # DFS scheduler options
                       dfs_monitor_enabled=True,
                       dfs_detection_threshold=1e-6,
                       dfs_holdoff_seconds=60.0,

                       # logging / output
                       log_path="/tmp/interference_log.jsonl",
                       log_every_injection=True,
                       output_when_idle="zeros"):
              """
              Constructor parameters appear in GRC as block parameters. All have defaults.
              """
              # Inputs: 3 interferers + 1 dfs monitor
              gr.sync_block.__init__(
                  self,
                  name='Interference Injector (3 DFS types) with DFS scheduler',
                  in_sig=[np.complex64, np.complex64, np.complex64, np.complex64],
                  out_sig=[np.complex64]
              )

              # Exposed parameters
              self.example_param = example_param
              self.sample_rate = float(sample_rate)
              self.mean_interval_seconds = float(mean_interval_seconds)
              self.inject_duration_seconds = float(inject_duration_seconds)

              self.pure_inject_enabled = bool(pure_inject_enabled)
              self.pure_injection_probability = float(pure_injection_probability)
              self.pure_inject_duration_seconds = float(pure_inject_duration_seconds)

              self.dfs_monitor_enabled = bool(dfs_monitor_enabled)
              self.dfs_detection_threshold = float(dfs_detection_threshold)
              self.dfs_holdoff_seconds = float(dfs_holdoff_seconds)

              self.log_path = str(log_path)
              self.log_every_injection = bool(log_every_injection)
              self.output_when_idle = str(output_when_idle)

              # Internal state
              self._time_accumulator_seconds = 0.0
              self._injection_remaining_seconds = 0.0
              self._next_wait_seconds = self._sample_next_wait()
              self._current_coeffs = None  # numpy array length 3 when injecting
              self._injection_id = 0

              self._is_current_pure = False
              self._pure_source_index = None  # 0..2

              # DFS state
              self._dfs_holdoff_remaining = 0.0
              self._last_dfs_detect_time = None

              # Ensure log folder exists
              log_dir = os.path.dirname(os.path.abspath(self.log_path))
              if log_dir and not os.path.exists(log_dir):
                  try:
                      os.makedirs(log_dir, exist_ok=True)
                  except Exception:
                      pass

          # ---------------------------
          # Internal helpers
          # ---------------------------
          def _sample_next_wait(self):
              mean = max(1e-12, float(self.mean_interval_seconds))
              return np.random.exponential(mean)

          def _write_log(self, record):
              try:
                  with open(self.log_path, "a", encoding="utf-8") as f:
                      f.write(json.dumps(record, default=str) + "\n")
              except Exception:
                  # Do not let logging failures crash the flowgraph
                  pass

          def _start_injection(self, force_pure=False):
              """
              Begin a new injection (mixed or pure). Logs injection start if enabled.
              """
              self._injection_id += 1
              self._is_current_pure = False
              self._pure_source_index = None

              will_be_pure = False
              if self.pure_inject_enabled:
                  if force_pure:
                      will_be_pure = True
                  else:
                      if np.random.random() < self.pure_injection_probability:
                          will_be_pure = True

              if will_be_pure:
                  src_idx = int(np.random.randint(0, 3))
                  self._pure_source_index = src_idx
                  self._is_current_pure = True
                  coeffs = np.zeros(3, dtype=float)
                  coeffs[src_idx] = 1.0
                  self._current_coeffs = coeffs
                  self._injection_remaining_seconds = float(self.pure_inject_duration_seconds)
              else:
                  coeffs = np.random.random(3)  # three random floats in [0,1)
                  self._current_coeffs = coeffs.astype(float)
                  self._injection_remaining_seconds = float(self.inject_duration_seconds)

              # Log injection start
              if self.log_every_injection:
                  dominant_idx = int(np.argmax(self._current_coeffs))
                  record = {
                      "event": "injection_start",
                      "injection_id": int(self._injection_id),
                      "start_time_utc": datetime.now(timezone.utc).isoformat(),
                      "is_pure_injection": bool(self._is_current_pure),
                      "pure_source_index": None if self._pure_source_index is None else int(self._pure_source_index),
                      "pure_source_type": None if self._pure_source_index is None else INTERFERENCE_MAP.get(self._pure_source_index),
                      "mean_interval_seconds": float(self.mean_interval_seconds),
                      "inject_duration_seconds": float(self._injection_remaining_seconds),
                      "coefficients": { INTERFERENCE_MAP[i]: float(self._current_coeffs[i]) for i in range(3) },
                      "dominant_index": dominant_idx,
                      "dominant_type": INTERFERENCE_MAP.get(dominant_idx, f"input_{dominant_idx}")
                  }
                  self._write_log(record)

              # reset wait accumulator and sample next wait for after injection
              self._time_accumulator_seconds = 0.0
              self._next_wait_seconds = self._sample_next_wait()

          def _handle_dfs_detection(self, dfs_power):
              """
              Called when DFS detection threshold is exceeded.
              Terminates any active injection, enters hold-off, and logs the event.
              """
              # If an injection was active, log its termination
              if self._injection_remaining_seconds > 0.0 and self.log_every_injection:
                  record_term = {
                      "event": "injection_terminated_by_dfs",
                      "injection_id": int(self._injection_id),
                      "time_utc": datetime.now(timezone.utc).isoformat(),
                      "remaining_injection_seconds": float(self._injection_remaining_seconds)
                  }
                  self._write_log(record_term)

              # Clear injection state
              self._injection_remaining_seconds = 0.0
              self._current_coeffs = None
              self._is_current_pure = False
              self._pure_source_index = None

              # Enter hold-off
              self._dfs_holdoff_remaining = float(self.dfs_holdoff_seconds)
              self._last_dfs_detect_time = datetime.now(timezone.utc)

              # Log DFS detection
              record = {
                  "event": "dfs_detected",
                  "time_utc": datetime.now(timezone.utc).isoformat(),
                  "dfs_power": float(dfs_power),
                  "holdoff_seconds": float(self._dfs_holdoff_remaining)
              }
              self._write_log(record)

              # Reset waiting accumulator so schedule restarts after hold-off
              self._time_accumulator_seconds = 0.0
              self._next_wait_seconds = self._sample_next_wait()

          # ---------------------------
          # Main processing
          # ---------------------------
          def work(self, input_items, output_items):
              # Inputs: in0 (DFS Type 1), in1 (DFS Type 2), in2 (DFS Type 1+2), dfs_in (monitor)
              in0 = input_items[0]
              in1 = input_items[1]
              in2 = input_items[2]
              dfs_in = input_items[3]

              # samples to process
              n = min(len(in0), len(in1), len(in2), len(dfs_in))
              if n <= 0:
                  return 0

              elapsed_seconds = float(n) / max(1.0, float(self.sample_rate))
              out = np.empty(n, dtype=np.complex64)

              samples_filled = 0
              remaining_samples = n
              local_time = 0.0

              # Process by segments (idle / injection / hold-off boundaries)
              while remaining_samples > 0:
                  # Handle DFS hold-off first
                  if self._dfs_holdoff_remaining > 0.0:
                      seg_seconds = min(self._dfs_holdoff_remaining, elapsed_seconds - local_time)
                      seg_samples = int(math.floor(seg_seconds * self.sample_rate + 1e-12))
                      seg_samples = min(seg_samples, remaining_samples)
                      if seg_samples <= 0:
                          seg_samples = 1

                      # Idle output during hold-off
                      out[samples_filled:samples_filled+seg_samples] = 0

                      used_seconds = float(seg_samples) / self.sample_rate
                      self._dfs_holdoff_remaining -= used_seconds
                      local_time += used_seconds
                      remaining_samples -= seg_samples
                      samples_filled += seg_samples

                      # Continue, still monitor dfs_in
                      continue

                  # If not currently injecting, we are waiting
                  if self._injection_remaining_seconds <= 0.0:
                      time_until_next = self._next_wait_seconds - self._time_accumulator_seconds
                      time_until_next = max(0.0, time_until_next)

                      # If next injection starts within this chunk
                      if local_time + time_until_next < elapsed_seconds:
                          seg_seconds = time_until_next
                          seg_samples = int(math.floor(seg_seconds * self.sample_rate + 1e-12))
                          seg_samples = min(seg_samples, remaining_samples)
                          if seg_samples <= 0:
                              seg_samples = 1

                          # Idle output
                          out[samples_filled:samples_filled+seg_samples] = 0

                          # Check DFS power over this idle segment
                          dfs_segment = dfs_in[samples_filled:samples_filled+seg_samples]
                          dfs_power = float(np.mean(np.abs(dfs_segment) ** 2)) if seg_samples > 0 else 0.0

                          used_seconds = float(seg_samples) / self.sample_rate
                          self._time_accumulator_seconds += used_seconds
                          local_time += used_seconds
                          remaining_samples -= seg_samples
                          samples_filled += seg_samples

                          # DFS detection?
                          if self.dfs_monitor_enabled and dfs_power >= self.dfs_detection_threshold:
                              self._handle_dfs_detection(dfs_power)
                              continue

                          # Wait finished -> start injection if not suppressed
                          if self._time_accumulator_seconds >= self._next_wait_seconds - 1e-12:
                              if self._dfs_holdoff_remaining <= 0.0:
                                  self._start_injection()
                              else:
                                  pass
                      else:
                          # Entire remaining chunk is idle
                          seg_samples = remaining_samples
                          out[samples_filled:samples_filled+seg_samples] = 0

                          dfs_segment = dfs_in[samples_filled:samples_filled+seg_samples]
                          dfs_power = float(np.mean(np.abs(dfs_segment) ** 2)) if seg_samples > 0 else 0.0

                          used_seconds = float(seg_samples) / self.sample_rate
                          self._time_accumulator_seconds += used_seconds
                          local_time += used_seconds
                          remaining_samples -= seg_samples
                          samples_filled += seg_samples

                          if self.dfs_monitor_enabled and dfs_power >= self.dfs_detection_threshold:
                              self._handle_dfs_detection(dfs_power)
                              continue
                          break
                  else:
                      # Injection active
                      seg_seconds = min(self._injection_remaining_seconds, elapsed_seconds - local_time)
                      seg_samples = int(math.floor(seg_seconds * self.sample_rate + 1e-12))
                      seg_samples = min(seg_samples, remaining_samples)
                      if seg_samples <= 0:
                          seg_samples = 1

                      start_idx = samples_filled
                      end_idx = samples_filled + seg_samples

                      # Monitor DFS inside injection window
                      dfs_segment = dfs_in[start_idx:end_idx]
                      dfs_power = float(np.mean(np.abs(dfs_segment) ** 2)) if seg_samples > 0 else 0.0

                      if self.dfs_monitor_enabled and dfs_power >= self.dfs_detection_threshold:
                          # Handle DFS detection: terminate injection immediately
                          self._handle_dfs_detection(dfs_power)
                          out[start_idx:end_idx] = 0
                          used_seconds = float(seg_samples) / self.sample_rate
                          local_time += used_seconds
                          remaining_samples -= seg_samples
                          samples_filled += seg_samples
                          continue

                      # No DFS detection -> produce injection output
                      if self._is_current_pure and self._pure_source_index is not None:
                          if self._pure_source_index == 0:
                              out[start_idx:end_idx] = in0[start_idx:end_idx]
                          elif self._pure_source_index == 1:
                              out[start_idx:end_idx] = in1[start_idx:end_idx]
                          elif self._pure_source_index == 2:
                              out[start_idx:end_idx] = in2[start_idx:end_idx]
                          else:
                              out[start_idx:end_idx] = 0
                      else:
                          a, b, c = self._current_coeffs.tolist() if self._current_coeffs is not None else (0.0, 0.0, 0.0)
                          out[start_idx:end_idx] = (a * in0[start_idx:end_idx]
                                                    + b * in1[start_idx:end_idx]
                                                    + c * in2[start_idx:end_idx])

                      used_seconds = float(seg_samples) / self.sample_rate
                      self._injection_remaining_seconds -= used_seconds
                      local_time += used_seconds
                      remaining_samples -= seg_samples
                      samples_filled += seg_samples

                      # If injection ended, reset state
                      if self._injection_remaining_seconds <= 0.0:
                          self._current_coeffs = None
                          self._is_current_pure = False
                          self._pure_source_index = None
                          self._time_accumulator_seconds = 0.0
                          self._next_wait_seconds = self._sample_next_wait()

              # write output buffer
              output_items[0][:n] = out
              return n
    dfs_detection_threshold: '1e-06'
    dfs_holdoff_seconds: '60.0'
    dfs_monitor_enabled: 'True'
    example_param: '1.0'
    inject_duration_seconds: '10'
    log_every_injection: 'True'
    log_path: '"Injection.json"'
    mean_interval_seconds: '2'
    output_when_idle: '"Zeros"'
    pure_inject_duration_seconds: '20'
    pure_inject_enabled: 'True'
    pure_injection_probability: '0.25'
    sample_rate: samp_rate
  states: {}
- name: epy_block_8
  id: epy_block
  parameters:
    _source_code: |
      """
      DFS Monitor Signal Generator (STANDARD DFS TEST WAVEFORM)

      Generates radar-like pulses used as the DFS detection input.
      Follows standard DFS radar characteristics:
      - Pulse width: 1 µs
      - PRF: 300 Hz
      - Amplitude: 0.1
      - Noise floor: 1e-7
      - Sample rate: 20 MHz
      """

      import numpy as np
      from gnuradio import gr
      import math

      class blk(gr.sync_block):
          def __init__(self,
                       sample_rate=20e6,          # STANDARD DFS test bandwidth
                       pulse_width_us=1.0,        # 1 µs pulse width
                       prf_hz=300.0,              # Pulse repetition frequency
                       pulse_amplitude=0.1,       # Radar peak amplitude
                       noise_power=1e-7):         # Noise floor power
              gr.sync_block.__init__(
                  self,
                  name="DFS Monitor (Standard Radar)",
                  in_sig=None,
                  out_sig=[np.complex64]
              )

              self.sample_rate = float(sample_rate)
              self.pulse_width_seconds = float(pulse_width_us) * 1e-6
              self.prf_hz = float(prf_hz)
              self.pulse_amplitude = float(pulse_amplitude)
              self.noise_power = float(noise_power)

              # Derived parameters
              self.pulse_samples = int(self.pulse_width_seconds * self.sample_rate)
              self.samples_per_pulse_period = int(self.sample_rate / self.prf_hz)

              # Internal counter
              self._sample_counter = 0

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)

              # Time vector
              t = (self._sample_counter + np.arange(n)) / self.sample_rate

              # Base noise floor
              sigma = math.sqrt(self.noise_power / 2.0)
              noise = (np.random.normal(scale=sigma, size=n) +
                       1j * np.random.normal(scale=sigma, size=n))

              # Start with noise only
              sig = noise.astype(np.complex64)

              # Radar pulse periodicity logic
              for i in range(n):
                  sample_index = self._sample_counter + i
                  pos_in_period = sample_index % self.samples_per_pulse_period

                  if pos_in_period < self.pulse_samples:
                      # Insert radar pulse (simple CW pulse)
                      sig[i] += self.pulse_amplitude

              # Output
              out[:] = sig
              self._sample_counter += n
              return n
    noise_power: '1e-07'
    prf_hz: '300.0'
    pulse_amplitude: '0.1'
    pulse_width_us: '5000'
    sample_rate: '20000000.0'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '5.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: Injection_Frequency
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: Injection_Frequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: int(5.44e6)
    fftsize: '1024'
    name: '"Transmitted"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: Injection_Frequency
    fftsize: '1024'
    name: '"Recieved Watterfall Plot"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Trabsmitted"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Recived Time Domain"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: int(5.44e6)
    fftsize: '1024'
    name: '"Transmitted"'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: Injection_Frequency
    fftsize: '1024'
    name: '"Recieved Frequency Domain"'
    type: complex
  states: {}

connections:
- [epy_block_0, '0', epy_block_7, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', qtgui_waterfall_sink_x_0, '0']
- [epy_block_1, '0', epy_block_7, '1']
- [epy_block_1, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_0, '0']
- [epy_block_1, '0', qtgui_waterfall_sink_x_0, '0']
- [epy_block_2, '0', epy_block_7, '2']
- [epy_block_2, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_2, '0', qtgui_waterfall_sink_x_0, '0']
- [epy_block_3, '0', epy_block_7, '3']
- [epy_block_3, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_3, '0', qtgui_time_sink_x_0, '0']
- [epy_block_3, '0', qtgui_waterfall_sink_x_0, '0']
- [epy_block_4, '0', epy_block_7, '0']
- [epy_block_4, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_4, '0', qtgui_time_sink_x_0, '0']
- [epy_block_4, '0', qtgui_waterfall_sink_x_0, '0']
- [epy_block_5, '0', epy_block_7, '1']
- [epy_block_6, '0', epy_block_7, '2']
- [epy_block_6, '0', qtgui_time_sink_x_0, '0']
- [epy_block_7, '0', iio_pluto_sink_0, '0']
- [epy_block_8, '0', epy_block_7, '3']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
